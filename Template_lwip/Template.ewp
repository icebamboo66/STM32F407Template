# IAR project Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40XX
  ICCARM.CCIncludePath2: APP\inc; APP\src; BSP\SYSTEM\delay; BSP\SYSTEM\sys; LIB\STM32F4xx_StdPeriph_Driver\inc; BSP\LED; USMART; BSP\LCD; BSP\SYSTEM\usart; LIB\STM32F4xx_StdPeriph_Driver\src; LIB\STM32F4x7_ETH_Driver\inc; LIB\STM32F4x7_ETH_Driver\src; BSP\ETHERNET; BSP\MALLOC; BSP\LWIP\lwip-1.4.1\src\include; BSP\LWIP\lwip-1.4.1\src\include\ipv4; BSP\LWIP\lwip-1.4.1\src\include\netif; BSP\LWIP; BSP\LWIP\arch; BSP\LWIP\lwip_app\lwip_comm; BSP\TIMER; BSP\KEY; BSP\SRAM; BSP\ADC; BSP\BEEP; BSP\InterTemperate; BSP\RTC; BSP\LWIP\lwip_app\lwip_client_tcp; BSP\LWIP\lwip_app\lwip_server_tcp; BSP\LWIP\lwip_app\lwip_udp; BSP\LWIP\lwip_app\web_server_demo; BSP\LWIP\lwip_app\web_server_demo\makefsdata; BSP\LWIP\lwip_app\web_server_demo\makefsdata\fs; BSP\LWIP\lwip_app\web_server_demo\makefsdata\fs\image
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.srec
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP/inc
    APP/inc/: startup_stm32f40xx.s stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.h system_stm32f4xx.h
  group APP/src
    APP/src/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group BSP/ADC
    BSP/ADC/: adc.c
  group BSP/BEEP
    BSP/BEEP/: beep.c
  group BSP/ETHERNET
    BSP/ETHERNET/: lan8720.c lan8720.h
  group BSP/InterTemperate
    BSP/InterTemperate/: temperature.c
  group BSP/KEY
    BSP/KEY/: key.c key.h
  group BSP/LCD
    BSP/LCD/: FONT.H lcd.c lcd.h
  group BSP/LED
    BSP/LED/: led.c led.h
  group BSP/LWIP/api
    BSP/LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group BSP/LWIP/arch
    BSP/LWIP/arch/: sys_arch.c
  group BSP/LWIP/core
    BSP/LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    BSP/LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c lwip_sys.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group BSP/LWIP/lwip_app
    BSP/LWIP/lwip_app/web_server_demo/: fs.c httpd.c httpd_cgi_ssi.c
    BSP/LWIP/lwip_app/lwip_comm/: lwip_comm.c
    BSP/LWIP/lwip_app/lwip_client_tcp/: tcp_client_demo.c
    BSP/LWIP/lwip_app/lwip_server_tcp/: tcp_server_demo.c
    BSP/LWIP/lwip_app/lwip_udp/: udp_demo.c
  group BSP/LWIP/netif
    BSP/LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group BSP/MALLOC
    BSP/MALLOC/: malloc.c malloc.h
  group BSP/RTC
    BSP/RTC/: rtc.c
  group BSP/SRAM
    BSP/SRAM/: sram.c sram.h
  group BSP/SYSTEM/delay
    BSP/SYSTEM/delay/: delay.c delay.h
  group BSP/SYSTEM/sys
    BSP/SYSTEM/sys/: sys.c sys.h
  group BSP/SYSTEM/usart
    BSP/SYSTEM/usart/: usart.c usart.h
  group BSP/TIMER
    BSP/TIMER/: timer.c timer.h
  group LIB/STM32F4x7_ETH_Driver
    LIB/STM32F4x7_ETH_Driver/: Release_Notes.html
  group LIB/STM32F4x7_ETH_Driver/inc
    LIB/STM32F4x7_ETH_Driver/inc/: stm32f4x7_eth.h stm32f4x7_eth_conf.h
  group LIB/STM32F4x7_ETH_Driver/src
    LIB/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group LIB/STM32F4xx_StdPeriph_Driver/inc
    LIB/STM32F4xx_StdPeriph_Driver/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group LIB/STM32F4xx_StdPeriph_Driver/src
    LIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group USMART
    USMART/: usmart.c usmart.h usmart_config.c usmart_str.c usmart_str.h
